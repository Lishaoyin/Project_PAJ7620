# Keil uVision project PAJ7620.uvprojx, settings and files
target PAJ7620 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PAJ7620
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\Delay;..\HARDWARE\GPIO;..\HARDWARE\IIC_Simulation;..\HARDWARE\PAJ7620;..\SYSTEM;..\USER;..\HARDWARE\NVIC;..\HARDWARE\EXTI;..\HARDWARE\TIM_PWMOUT;..\HARDWARE\PWMDevice
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx_it.c sys.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/Delay/: delay.c
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/IIC_Simulation/: IIC.c
    ../HARDWARE/PAJ7620/: PAJ7620.c PAJ7620_InitArray.c
    ../HARDWARE/NVIC/: NVIC.c
    ../HARDWARE/EXTI/: EXTI.c
    ../HARDWARE/TIM_PWMOUT/: TIM_PWMOUT.c
    ../HARDWARE/PWMDevice/: PWMDevice.c
